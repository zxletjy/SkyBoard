# Keil uVision project SkyBoard.uvprojx, settings and files
target SkyBoard (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SkyBoard +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\applications;..\..\drivers;..\..\Libraries\CMSIS;..\..\Libraries\inc;..\..\Libraries\src;..\..\Math;..\..\USBLIB;..\..\usb_virtual_serial
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../../applications/: mian.c Config.c Config.h DT.c DT.h Filter.c Filter.h FlyControl.c FlyControl.h IMU.c IMU.h Motor.c Motor.h Param.c Param.h PID.c PID.h RC.c RC.h Scheduler.c Scheduler.h
  group math
    ../../Math/: Math.c Math.h Quaternion.c Quaternion.h Vector3.h
  group bsp
    ../../drivers/: board.c board.h EEPROM.c EEPROM.h I2C_soft.c I2C_soft.h LED.c LED.h MPU6050.c MPU6050.h PWM.c PWM.h PWM_In.c PWM_In.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h usart1.c usart1.h ultran.c ultran.h
  group usb virtual serial
    ../../usb_virtual_serial/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
    ../../USBLIB/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group libraries
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ../../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
